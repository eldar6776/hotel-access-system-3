# Keil uVision project IC_RC1.uvprojx, settings and files
target IC_RC1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: ic +hex
  BeforeMake: Run\fwbuild.bat
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=Out Exe\ic.axf
  AfterMake: Run\ic.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx,ROOM_THERMOSTAT,APPLICATION,USE_WATCHDOG
  c misc: -Iscatter_file_path
  c include: ..\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32F746;..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\BSP\Components;..\Middlewares\ST\STemWin\inc;..\Middlewares\ST\STemWin\png;..\..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Run\ic.sct
  group DisplayImage
    ../Src/Display/: btn_ok.c btn_dnd_0.c btn_dnd_1.c btn_maid_0.c btn_maid_1.c btn_weather.c btn_rst_sos_1.c btn_door_open.c scattered_clouds.c thunderstorm.c shower_rain.c few_clouds.c clear_sky.c snow.c mist.c rain.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/HARDWARE
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/STM32F746/: stm32746g.c stm32746g_ts.c stm32746g_qspi.c stm32746g_sdram.c stm32746g_eeprom.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_usart.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2s.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_spi.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf.c LCDConf.c GUI_X.c
  group Middlewares/STemWin/PNG
    ../Middlewares/ST/STemWin/png/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c IMAGE_PNG.c infback.c inffast.c inftrees.c png.c pngerror.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c inflate.c
  group Middlewares/STemWin/Lib
    ../Middlewares/ST/STemWin/Lib/: STemWin540_CM7_Keil.lib
  group Application/MDK-ARM
    ./Asm/: startup_stm32f746xx.s incl_logo_png.s incl_gui_bmp.s
  group Application/User
    ../Src/: stm32f7xx_it.c onewire.c display.c logger.c rs485.c room.c dio.c main.c
    ../../Common/: common.c
software components: CMSIS:CORE 5.3.0
